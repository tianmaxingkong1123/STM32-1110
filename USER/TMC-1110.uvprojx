# Keil uVision project TMC-1110.uvprojx, settings and files
target TMC (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TMC-1110 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\FWLIB\inc;..\SYSTEM;..\CORE;..\HARD;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARD\GPIO;..\HARD\SPI;..\USMART;..\HARD\EEPROM;..\HARD\TMC262;..\HARD\TMC429;..\HARD\Globals;..\HARD\Driver;..\HARD\Commands;..\HARD\Control;..\HARD\CAN;..\HARD\Encoder
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group HARD
    ../HARD/GPIO/: GPIO.c
    ../HARD/SPI/: SPI.c
    ../HARD/TMC429/: TMC429.c
    ../HARD/TMC262/: TMC262.c
    ../HARD/EEPROM/: AT25128B.c
    ../HARD/Globals/: Globals.c
    ../HARD/Driver/: driver.c
    ../HARD/Commands/: Commands.c
    ../HARD/Control/: control.c
    ../HARD/CAN/: can.c
    ../HARD/Encoder/: Encoder.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
